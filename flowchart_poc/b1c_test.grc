options:
  parameters:
    author: syml
    generate_options: qt_gui
    id: b1c_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: data_sps
  id: variable
  parameters:
    comment: |-
      sps of b1c
      data
    value: '100'
  states: {}
- name: f_sc_b1c_a
  id: variable
  parameters:
    comment: |-
      frequency of 
      subcarrier a
      I way
    value: 1.023e6
  states: {}
- name: f_sc_b1c_b
  id: variable
  parameters:
    comment: |-
      frequency of 
      subcarrier b
      Q way
    value: 6.138e6
  states: {}
- name: pilot_sps
  id: variable
  parameters:
    comment: |-
      sps of b1c
      pilot
    value: 1.023e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.138e6*8
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 6.138e6*8
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    comment: |-
      just generating some random data
      to test the modulation system...
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: analog_random_uniform_source_x_0_0
  id: analog_random_uniform_source_x
  parameters:
    comment: |-
      generate the pilot data
      to test the modulation system...
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: analog_random_uniform_source_x_0_0_0
  id: analog_random_uniform_source_x
  parameters:
    comment: |-
      generate the pilot data
      to test the modulation system...
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: hier_b1c_boc_0
  id: hier_b1c_boc
  parameters:
    data_sps: '100'
    delay: '0'
    f_sc_b1c_a: 1.023e6
    f_sc_b1c_b: 1.023e6 * 6
    pilot_sps: 1.023e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', hier_b1c_boc_0, '0']
- [analog_random_uniform_source_x_0_0, '0', hier_b1c_boc_0, '2']
- [analog_random_uniform_source_x_0_0_0, '0', hier_b1c_boc_0, '1']
- [hier_b1c_boc_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0

options:
  parameters:
    author: syml
    category: '[BDS]'
    generate_options: hb
    id: hier_B1CDataPilot2Vector
    output_language: python
    title: B1C_DataPilot2Vector
  states: {}

blocks:
- name: oct2vec_ans
  id: variable
  parameters:
    value: oct2vec.oct2vec(oct_pilot)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: oct2vec_ans[1]
  states: {}
- name: oct2vec
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      from typing import List, Tuple

      import numpy as np


      def oct2vec(oct: str) -> Tuple[int, List[int]]:
          length = len(oct) * 3
          data = []
          for i in range(len(oct)):
              data.append(int(oct[i]) >> 2 & 1)
              data.append(int(oct[i]) >> 1 & 1)
              data.append(int(oct[i]) & 1)
          return length, data
  states: {}
- name: oct_pilot
  id: parameter
  parameters:
    label: pilot
    type: str
    value: ''
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}

connections:
- [blocks_vector_source_x_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0

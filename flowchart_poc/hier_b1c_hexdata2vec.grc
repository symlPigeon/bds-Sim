options:
  parameters:
    category: '[BDS]'
    generate_options: hb
    id: hier_B1C_hexdata2vec
    output_language: python
    title: B1C_HexData2Vec
  states: {}

blocks:
- name: hex2vec_ans
  id: variable
  parameters:
    value: hex2vec.hex2vec(hex_data)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: hex2vec_ans[1]
  states: {}
- name: hex2vec
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nfrom typing import List, Tuple\n\nimport numpy as np\n\n\ndef hex2vec(data: str) -> Tuple[int, List[int]]:\n    length = len(data) * 4\n    vec = []\n    for d in data:\n        i = int(d, 16)\n        vec.append((i >> 3) & 0x1)\n        vec.append((i >> 2) & 0x1)\n        vec.append((i >> 1) & 0x1)\n        vec.append(i & 0x1)\n    return length, vec\n        \n"
  states: {}
- name: hex_data
  id: parameter
  parameters:
    label: data
    type: str
    value: ''
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}

connections:
- [blocks_vector_source_x_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0

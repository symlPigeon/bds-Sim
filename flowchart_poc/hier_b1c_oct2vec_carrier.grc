options:
  parameters:
    category: '[BDS]'
    generate_options: hb
    id: hier_B1CCarrierPilot2Vector
    output_language: python
    title: B1C_CarrierPilot2Vector
  states: {}

blocks:
- name: oct2vec_ans1
  id: variable
  parameters:
    value: oct2vec.oct2vec(oct_pilot)
  states: {}
- name: oct2vec_ans2
  id: variable
  parameters:
    value: oct2vec.oct2vec(oct_subpilot)
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      Two sources' symbol rate should be equal.
      After repeat of 1.023e4,
      the symbol rate becomes 1.023Mcps
    interp: int(1.023e4)
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      B1C Pilot
      Master Code
      10230 symbols, 10 ms, 1.023Mcps
    repeat: 'True'
    type: byte
    vector: oct2vec_ans1[1]
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    comment: |-
      B1C Pilot
      Sub Code
      1800 symbols, 18000ms, 100cps
    repeat: 'True'
    type: byte
    vector: oct2vec_ans2[1]
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: oct2vec
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      from typing import List, Tuple

      import numpy as np


      def oct2vec(oct: str) -> Tuple[int, List[int]]:
          length = len(oct) * 3
          data = []
          for i in range(len(oct)):
              data.append(int(oct[i]) >> 2 & 1)
              data.append(int(oct[i]) >> 1 & 1)
              data.append(int(oct[i]) & 1)
          return length, data
  states: {}
- name: oct_pilot
  id: parameter
  parameters:
    label: pilot
    type: str
    value: ''
  states: {}
- name: oct_subpilot
  id: parameter
  parameters:
    label: subpilot
    type: str
    value: ''
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}

connections:
- [blocks_repeat_0, '0', blocks_xor_xx_0, '1']
- [blocks_vector_source_x_0, '0', blocks_xor_xx_0, '0']
- [blocks_vector_source_x_1, '0', blocks_repeat_0, '0']
- [blocks_xor_xx_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0

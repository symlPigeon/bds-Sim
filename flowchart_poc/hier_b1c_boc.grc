options:
  parameters:
    author: syml
    category: '[BDS]'
    generate_options: hb
    id: hier_b1c_boc
    max_nouts: '1'
    output_language: python
    title: B1C_BOC
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 6.138e6*8
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0.25'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: math.sqrt(1/11)
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: math.sqrt(29/44)
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    comment: sc_B1C_b
    freq: f_sc_b1c_b
    offset: '-1'
    phase: 3.1415926/2
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    comment: sc_B1C_a
    freq: f_sc_b1c_a
    offset: '-1'
    phase: 3.1415926/2
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    comment: D_b1c_data
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    comment: C_b1c_pilot
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    comment: C_b1c_data
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: s_b1c_data(t)
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: s_b1c_pilot_b(t)
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    comment: s_b1c_pilot_a(t)
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      data sps is 100
      here should be an interpolation
    interp: int(samp_rate / data_sps)
    type: byte
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    comment: pilot sps is 1.023M
    interp: int(samp_rate / pilot_sps)
    type: byte
  states: {}
- name: blocks_repeat_1_0
  id: blocks_repeat
  parameters:
    comment: pilot sps is 1.023M
    interp: int(samp_rate / pilot_sps)
    type: byte
  states: {}
- name: data_sps
  id: parameter
  parameters:
    label: data_sps
    type: eng_float
    value: '100'
  states: {}
- name: delay
  id: parameter
  parameters:
    label: delay
    type: eng_float
    value: '0'
  states: {}
- name: f_sc_b1c_a
  id: parameter
  parameters:
    label: f_sc_b1c_a
    type: eng_float
    value: 1.023e6
  states: {}
- name: f_sc_b1c_b
  id: parameter
  parameters:
    label: f_sc_b1c_b
    type: eng_float
    value: 1.023e6 * 6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: D_b1c_data
    type: byte
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: C_b1c_data
    type: byte
  states: {}
- name: pad_source_0_0_0
  id: pad_source
  parameters:
    label: C_b1c_pilot
    type: byte
  states: {}
- name: pilot_sps
  id: parameter
  parameters:
    label: pilot_sps
    type: eng_float
    value: 1.023e6
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_const_source_x_1, '0', blocks_multiply_xx_1, '0']
- [analog_const_source_x_2, '0', blocks_multiply_xx_1_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '2']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '2']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_xx_0, '3']
- [blocks_add_const_vxx_0_1, '0', blocks_multiply_xx_1, '1']
- [blocks_add_const_vxx_0_1, '0', blocks_multiply_xx_1_0, '2']
- [blocks_add_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_char_to_float_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0, '0', pad_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1_0, '0', blocks_float_to_complex_0, '1']
- [blocks_repeat_0, '0', blocks_char_to_float_0, '0']
- [blocks_repeat_1, '0', blocks_char_to_float_1, '0']
- [blocks_repeat_1_0, '0', blocks_char_to_float_1_0, '0']
- [pad_source_0, '0', blocks_repeat_0, '0']
- [pad_source_0_0, '0', blocks_repeat_1_0, '0']
- [pad_source_0_0_0, '0', blocks_repeat_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
